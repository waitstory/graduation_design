# Keil uVision project Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\从机代码
  group Slave
    ./: main.c DHT11.c BH1750.c I2C.c Delay.c STARTUP.A51
