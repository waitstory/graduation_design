# Keil uVision project Project_AS3x5x6x.uvproj, settings and files
target AS62 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project_AS62 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source_Files\drv_mcu\inc;.\Source_Files\drv_periph\inc
  group app
    ./Source_Files/app/: main.c
  group drv_mcu
    ./Source_Files/drv_mcu/src/: drv_delay.c drv_led.c drv_uart.c
  group drv_periph
    ./Source_Files/drv_periph/src/: drv_AS62.c
